# Keil uVision project HW1.uvprojx, settings and files
target HW1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: ece353_base_project
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\3.20.4\CMSIS\Include;..\include;..\drivers\include;..\peripherals\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c ece353_hw1.s init_leds.s write_leds.s rotate_leds.s
  group HW1-Lib
    ./hw1-lib/: hw1.lib
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0
